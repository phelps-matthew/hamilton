options:
  parameters:
    author: mgp
    generate_options: qt_gui
    id: test_vhf
    output_language: python
    title: VHF Spectrum Analyzer
  states: {}

blocks:
- name: rx_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 5,0,1,1
    type: real
    value: 1710e6
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    start: 100e6
    step: 1e6
    stop: 250e6
    value: 140e6
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,4
    type: real
    value: '60'
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    name: '"Spectrum Analyzer"'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(rx_freq)
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
